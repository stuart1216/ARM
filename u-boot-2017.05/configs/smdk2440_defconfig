## u-boot-2017.05/configs/smdk2440_defconfig
```kconfig
CONFIG_ARM=y
CONFIG_TARGET_SMDK2440=y
CONFIG_SYS_PROMPT="SMDK2440 # "
/* CONFIG_CMD_SETEXPR is not set */
CONFIG_CMD_UBI=n
```
